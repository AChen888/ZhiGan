# Keil uVision project Refactor_ gasViewer.uvprojx, settings and files
target Refactor_ gasViewer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Refactor_V1_3_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F3xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../AD7171;../App;../RTT;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Collect_Process;../LCD;../GUI;../GUI/ui;../GUI/user;../Core/Src;../IRDA;../Store;../SHT;../ALARM
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: Refactor_ gasViewer\Refactor_V1.2.sct
  link misc: --no_autoat
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group AD7171
    ../AD7171/: ad7171.c
  group Application/User/App
    ../App/: CollectTask.c GuiTask.c CommTask.c appConfig.c KeyTask.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Collect_Process
    ../Collect_Process/: ad_conversion.c ad_config.c ad_compensate.c ad_amend.c
  group LCD
    ../LCD/: lcd.c lcd_init.c
  group GUI/ui
    ../GUI/ui/: ui_base.c ui_button.c ui_checkbox.c ui_confirm.c ui_digital.c ui_draw.c ui_edit.c ui_event.c ui_font_ascii.c ui_font16.c ui_font24.c ui_font32.c ui_font48.c ui_font64.c ui_fontC64.c ui_icon.c ui_key.c ui_lable.c ui_list.c ui_menu.c ui_multi.c ui_realdata.c ui_win.c
  group GUI/user
    ../GUI/user/: win_main.c win_Auth.c win_menu.c win_SystemSet.c win_information.c win_DateTime.c win_Current.c win_Usart.c win_Life.c win_startup.c win_save.c win_Product.c
  group IRDA
    ../IRDA/: remote.c
  group Store
    ../Store/: bsp_w25qxx_driver.c bsp_fram_driver.c
  group SHT
    ../SHT/: SHT31.c
  group ALARM
    ../ALARM/: Alarm.c
software components: CMSIS:CORE 4.3.0
